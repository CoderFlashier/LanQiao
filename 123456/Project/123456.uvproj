# Keil uVision project 123456.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 123456 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Source Group 1
    ./: main.c
    ../Driver/: timer.c init.c led.c seg.c key.c buzz_relay.c ds1302.c iic.c onewire.c ultrasonic.c
