# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./User/: dsp.c iic.c keyboard.c main.c pcf8591.c sonic.c task.c
