# Keil uVision project ultrasonic.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ultrasonic +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: init.c init.h main.c seg.c seg.h timer.c timer.h key.h key.c ultrasonic.h ultrasonic.c ds1302.c ds1302.h iic.h iic.c onewire.c onewire.h
